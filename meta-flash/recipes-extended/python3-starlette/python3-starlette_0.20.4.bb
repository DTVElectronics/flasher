SUMMARY = "The little ASGI library that shines"
HOMEPAGE = "https://www.starlette.io/"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=11e8c8dbfd5fa373c703de492140ff7a"

inherit pypi setuptools3

SRC_URI[sha256sum] = "42fcf3122f998fefce3e2c5ad7e5edbf0f02cf685d646a83a08d404726af5084"
