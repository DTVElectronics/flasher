SUMMARY = "The little ASGI library that shines"
HOMEPAGE = "https://www.starlette.io/"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=11e8c8dbfd5fa373c703de492140ff7a"

inherit pypi setuptools3
